## boards/shields/generic-numpad/Kconfig.shield
```kconfig
config SHIELD_GENERIC_NUMPAD
    def_bool $(shields_list_contains,generic-numpad)
```
